<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rcv_single_fm</value></param>
<param><key>author</key><value>Nathan West</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Receive Single FM Station</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_number</value></param>
<param><key>value</key><value>int(10*(rf_frequency_h-98)) /2if rf_frequency_h&gt;=98 else 50 + int(10*(rf_frequency_h-88.1))/2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_channel_rate</value></param>
<param><key>value</key><value>audio_rate*5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(32., rf_rate, 96e3, 25e3, 50)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_frequency</value></param>
<param><key>value</key><value>98.1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_frequency_h</value></param>
<param><key>value</key><value>88.5</value></param>
<param><key>label</key><value>RF Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>88.0</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>108.0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>value</key><value>50</value></param>
<param><key>label</key><value>RF gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>90</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_rate</value></param>
<param><key>value</key><value>20e6</value></param>
<param><key>label</key><value>RF sample rate</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>100e3</value></param>
<param><key>step</key><value>200e3</value></param>
<param><key>stop</key><value>20e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_len</value></param>
<param><key>value</key><value>fm_taps.__len__()</value></param>
</block>
<block>
<key>analog_wfm_rcv</key>
<param><key>id</key><value>analog_wfm_rcv_0</value></param>
<param><key>audio_decimation</key><value>fm_channel_rate/audio_rate</value></param>
<param><key>quad_rate</key><value>fm_channel_rate</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0</value></param>
<param><key>decim</key><value>int(rf_rate/200e3)</value></param>
<param><key>channel</key><value>channel_number</value></param>
<param><key>atten</key><value>100</value></param>
<param><key>taps</key><value>fm_taps</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>fm_channel_rate</value></param>
<param><key>fc</key><value>rf_frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"Selected Channel"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>rf_rate</value></param>
<param><key>fc</key><value>rf_frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>name</key><value>"Received Spectrum"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>int(200e3)</value></param>
<param><key>interp</key><value>fm_channel_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>rf_frequency</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>rf_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_wfm_rcv_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_wfm_rcv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>pfb_decimator_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
